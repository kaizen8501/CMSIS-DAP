# Keil uVision project lpc11u35_w7500x_interface.uvproj, settings and files
target lpc11u35_w7500x_if (ARM-ADS)
  device: LPC11U35/501 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u35_w7500x_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_W7500x, BOARD_W7500x
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_Wiznet\DBG_W7500x;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/: system_LPC11Uxx.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/TOOLCHAIN_ARM_STD/: startup_LPC11Uxx.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c serial.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_NXP/TARGET_LPC11U35/: DAP_config.h gpio.c read_uid.c uart.c usbd_LPC11Uxx.c usb_buf.h
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM1.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group HAL-TARGET-W7500x
    ../../target/hal/DBG_Wiznet/DBG_W7500x/: target_reset_W7500x.c
target lpc11u35_lpc1768_mbed_bootloader (ARM-ADS)
  device: LPC11U35/401 NXP (founded by Philips)
  cpu: as above
  output: lpc11u35_lpc1768_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: TARGET_LPC11U35, __RTX, DBG_LPC1768, BOARD_SEEED_ARCH_PRO
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NXP\DBG_LPC1768;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\interface\cmsis;..\..\interface\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35_mbed_bootloader.sct
